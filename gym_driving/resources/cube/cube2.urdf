Commit message: Added cube class and modified URDF files.

File: gym_driving/resources/cube/cube2.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.4 0.4 0.4; visual mesh filename=cube.obj scale=0.4 0.4 0.4
