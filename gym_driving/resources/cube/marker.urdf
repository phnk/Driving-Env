Commit message: Finalized Driving-v0, Driving-v1

File: gym_driving/resources/cube/marker.urdf (robot description, URDF)
Before this commit: robot marker, 1 links, 0 joints
Links:
- link baseLink: geometry visual mesh filename=cube.obj scale=0.3 0.3 0.3
